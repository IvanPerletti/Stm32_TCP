# Keil uVision project MC_RF.uvprojx, settings and files
target MC_RF_withLIB (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: _stm32F4_i1 +hex
  AfterMake: fromelf.exe --bin --output ./obj/_stm32F4_i1.bin ./obj/_stm32F4_i1.axf
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __USB_DEBUG__ , USE_FULL_ASSERT , USE_STDPERIPH_DRIVER , STM32F4XX , STM32F40_41xxx,HSE_VALUE=8000000, ARM_MATH_CM4, __FPU_USED ,STM32F4XX,USE_STDPERIPH_DRIVER,USE_STM32F4_DISCOVERY, USE_USB_OTG_FS,
  c misc: --exceptions
  c include: User;Sys;..\__firmware\Libraries\CMSIS\Include;..\__firmware\Libraries\CMSIS\ST\STM32F4xx\Include;..\__firmware\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\__firmware\Utilities\STM32F4-Discovery;.\RTE\CMSIS;.\Gmm_Driver_Inc;.\Gmm_Driver_Inc\USB_Support_inc\usb_conf;.\Gmm_Driver_Inc\USB_Support_inc\usb_lib\cdc;.\Gmm_Driver_Inc\USB_Support_inc\usb_lib\core;.\Gmm_Driver_Inc\USB_Support_inc\usb_lib\otg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Device
    ./RTE/Device/STM32F407VG/: startup_stm32f407xx.s system_stm32f4xx.c
  group Libraries
    ./Gmm_DriverLib/: STM32F4xx_StdPeriph.lib Gmm_Driver.lib _USB_SupportDriver.lib
  group Sys
    ./Sys/: stm32f4xx_it.c
  group User
    ./User/: Main.cpp TAutoma_SerialTest.cpp TAutoma_EthTest.cpp TAutoma_SerialTest.h TAutoma_EthTest.h TDigitalPort.cpp tcpprotocol.cpp TAnalogPort.cpp ICan.cpp
  group STM32F4xx_StdPeriph_Driver
    ../__firmware/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_flash.c stm32f4xx_dma.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rtc.c
    ../__firmware/Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group GmmDriver
    ./Gmm_Driver_Src/: watchDog_i1.c TChronoMeter.cpp TClock.cpp TSerial.cpp TSerial232.cpp TSerial485.cpp TVirtual_Serial.cpp TVirtual_eth.cpp TEth.cpp TEthLAN8720.cpp
    ./Gmm_Driver_Inc/: stMessage.h TVirtual_Serial.h
  group CMSIS1
    ./RTE/CMSIS/: RTX_CM4.lib RTX_Conf_CM.c
  group STM32F4x7_ETH_Driver
    ../__firmware/Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group LwIp
    ./lwip/src/api/: tcpip.c api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c
    ./lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp_in.c tcp_out.c timers.c udp.c tcp.c
    ./lwip/src/core/ipv4/: ip_frag.c autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c
    ./lwip/port/STM32F4x7/Standalone/: ethernetif.c
    ./lwip/src/netif/: etharp.c
target GMM_Driver_LIB (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: as above
  output: Gmm_Driver +hex (library)
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DBG_USB_I1,USE_FULL_ASSERT,USE_STDPERIPH_DRIVER,STM32F4XX, STM32F40_41xxx,HSE_VALUE=8000000, ARM_MATH_CM4, __FPU_USED ,STM32F4XX,USE_STDPERIPH_DRIVER,USE_STM32F4_DISCOVER, USE_USB_OTG_FS, SCHAR_MAX=127 SHRT_MAX=32767
  c misc: --exceptions
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F4xx_StdPeriph_LIB (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: as above
  output: STM32F4xx_StdPeriph +hex (library)
  c flags: Optim=3 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: --exceptions
  c include: User;Sys;..\__firmware\Libraries\CMSIS\Include;..\__firmware\Libraries\CMSIS\ST\STM32F4xx\Include;..\__firmware\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\__firmware\Utilities\STM32F4-Discovery;.\RTE\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F4xx_USB_LIB (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: as above
  output: STM32_USB_Support_Drv +hex (library)
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_ASSERT,DBG_USB_I1,USE_STDPERIPH_DRIVER,STM32F4XX, HSE_VALUE=8000000, USE_STM32F4_DISCOVERY, USE_USB_OTG_FS, SCHAR_MAX=127 SHRT_MAX=32767,STM32F40_41xxx
  c misc: --exceptions
  c include: User;Sys;..\__firmware\Libraries\CMSIS\Include;..\__firmware\Libraries\CMSIS\ST\STM32F4xx\Include;..\__firmware\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\__firmware\Utilities\STM32F4-Discovery;.\RTE\CMSIS;.\Gmm_Driver_Inc\USB_Support_inc\usb_conf;.\Gmm_Driver_Inc\USB_Support_inc\usb_lib\cdc;.\Gmm_Driver_Inc\USB_Support_inc\usb_lib\core;.\Gmm_Driver_Inc\USB_Support_inc\usb_lib\otg
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target RF_Hiris (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: as above
  output: _MC_XX_YY_ZZ_OD4000-PA +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_ASSERT , USE_STDPERIPH_DRIVER , STM32F4XX , HSE_VALUE=8000000 , USE_STM32F4_DISCOVERY , USE_USB_OTG_FS , STM32F40_41xxx ,  _USB_DEBUG_ , USE_HIRIS
  c misc: --exceptions
  c include: User;Sys;..\__firmware\Libraries\CMSIS\Include;..\__firmware\Libraries\CMSIS\ST\STM32F4xx\Include;..\__firmware\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\__firmware\Utilities\STM32F4-Discovery;.\RTE\CMSIS;.\Gmm_Driver_Inc\USB_Support_inc\usb_conf;.\Gmm_Driver_Inc\USB_Support_inc\usb_lib\cdc;.\Gmm_Driver_Inc\USB_Support_inc\usb_lib\core;.\Gmm_Driver_Inc\USB_Support_inc\usb_lib\otg;.\Gmm_Driver_Inc;.\RTE\State_Machine
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target RF_GE_Inside (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: as above
  output: _MC_XX_WW_YY_ZZ_D4000-PD +hex
  AfterMake: fromelf.exe --bin --output ./obj/_MC_XX_WW_YY_ZZ_D4000-PD.bin ./obj/_MC_XX_WW_YY_ZZ_D4000-PD.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_ASSERT , USE_STDPERIPH_DRIVER , STM32F4XX , HSE_VALUE=8000000 , USE_STM32F4_DISCOVERY , USE_USB_OTG_FS , STM32F40_41xxx , USE_DLL
  c misc: --exceptions
  c include: User;Sys;..\__firmware\Libraries\CMSIS\Include;..\__firmware\Libraries\CMSIS\ST\STM32F4xx\Include;..\__firmware\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\__firmware\Libraries\STM32F4x7_ETH_Driver\inc;..\__firmware\Utilities\STM32F4-Discovery;.\RTE\CMSIS;.\Gmm_Driver_Inc\USB_Support_inc\usb_conf;.\Gmm_Driver_Inc\USB_Support_inc\usb_lib\cdc;.\Gmm_Driver_Inc\USB_Support_inc\usb_lib\core;.\Gmm_Driver_Inc\USB_Support_inc\usb_lib\otg;.\Gmm_Driver_Inc;.\RTE\State_Machine;.\lwip\src\include;.\lwip\src\include\lwip;.\lwip\src\include\netif;.\lwip\src\include\ipv4;.\lwip\port\STM32F4x7;.\lwip\port\STM32F4x7\Standalone
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
